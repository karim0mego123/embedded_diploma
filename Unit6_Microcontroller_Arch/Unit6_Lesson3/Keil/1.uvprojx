# Keil uVision project 1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab1_Unit6_Lesson3
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ../../../../../../STM_WorkSpace/asf/Src/: hal_KeyPad.c hal_lcd.c main.c mcal_stm32f103c6_exti.c mcal_stm32f103c6_RCC.c mcal_stm32f103c6_USART.c mcal_stm32f103X6_gpio.c syscalls.c sysmem.c
